# IAR project FreePLC_Bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKV44F256xxx16 NXP MKV44F256xxx16
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MKV46F256VLL16; TWR_KV46F150M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167,Pa182
  ICCARM.CCIncludePath2: CMSIS; board; drivers; source; startup; utilities
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: FreePLC_Bootloader.srec
  ILINK.IlinkOutputFile: FreePLC_Bootloader.out
  ILINK.IlinkIcfFile: MKV46F256xxx16_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MKV46F256xxx16 NXP MKV46F256xxx16
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG; CPU_MKV46F256VLL16; TWR_KV46F150M; TOWER
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: MKV46F256xxx16_flash.icf
  group (top)
    ./: MKV46F256xxx16_flash.icf
  group CMSIS
    CMSIS/: arm_common_tables.h arm_const_structs.h arm_math.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm4.h fsl_device_registers.h MKV46F16.h MKV46F16_features.h mpu_armv7.h system_MKV46F16.c system_MKV46F16.h
  group source
    source/: Driver.c Driver.h FAC_Port.c FAC_Port.h main.c Task.c Task.h
  group startup
    startup/: startup_MKV46F16.s
